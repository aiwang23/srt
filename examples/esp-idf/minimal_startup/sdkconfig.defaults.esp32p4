## examples/esp-idf/minimal_startup/sdkconfig.defaults.esp32p4
```kconfig
CONFIG_ESP32P4_REV_MIN_100=y
CONFIG_ESP32P4_REV_MIN_FULL=100
CONFIG_ESP32P4_REV_MAX_FULL=199
```
